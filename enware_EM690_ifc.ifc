Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2022-01-06T15:30:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 06 15:30:57 2022 * Host: DESKTOP-5NN4IDP * Database: C:\Users\PC-041\AppData\Local\Temp\{F4B9A32A-FC94-450F-81EB-5C7711FEAE10}\ifc * Database version: 5507 * Database creation date: Thu Jan 06 15:30:56 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 06 15:30:56 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 06 15:30:56 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: \\192.168.1.99\Vol-2-New\MEP 2022\Mark N\Project Fixture\Output\06-01-2022\EM690\EM690.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: EM690, EM690:EM690:5722
In: Level 1
Pset_DistributionFlowElementCommon - Reference: EM690
Constraints - Level: Level: Level 1; Offset: 0 mm; Work Plane: Level : Level 1; Default Elevation: 1219.2 mm
Dimensions - Area: 7.73394 m2; Volume: 0.111479 m3
Identity Data - Mark: 1; Description: Free Standing Platform Operated Multi-Spray Shower with Hand Operated Eye/Face Wash; Model: EM690 EM690; Type Name: EM690; URL: website link: www.enware.com.au
Other - Category: Plumbing Fixtures; Family: EM690: EM690; Family and Type: EM690: EM690; Schedule Level: Level: Level 1; Type: EM690: EM690; Type Id: EM690: EM690; Family Name: EM690
Phasing - Phase Created: New Construction
